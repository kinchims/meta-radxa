FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://cfg80211.cfg;nopatch=1;md5=0f167f2037c4e737c38e4f1c815083ad"